# IAR project bldc_svpwm_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100; EXT_BOARD=MC300
  ICCAVR32.CCDiagSuppress: Pa082,Pe167
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\..\DRIVERS\; ..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\BOARDS\; ..\..\..\..\..\..\COMPONENTS\DISPLAY\DIP204\; ..\..\..\..\..\..\SERVICES\DELAY\; ..\..\..\..\..\..\SERVICES\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\HALL_ESTIMATOR\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\MOTOR_DRIVER\BLDC_MOTOR\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\SVPWM\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\USHELL\; ..\..\..\..\..\..\SERVICES\FREERTOS\Source\portable\IAR\AVR32_UC3\; ..\..\..\..\..\..\UTILS\LIBS\DSPLIB\INCLUDE\; ..\..\..\..\..\..\UTILS\LIBS\DRIVERS\AT32UC3A\INCLUDE\; ..\..\; ..\..\CONF\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.AIncludePaths: ..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\UTILS\LIBS\DRIVERS\AT32UC3A\INCLUDE\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3A\0512\IAR\lnkuc3a0512.xcl
  group (top)
    ../../: bldc_svpwm_example.c mc_control.c mc_driver.c
  group Librairies
    ../../../../../../UTILS/LIBS/DRIVERS/AT32UC3A/IAR/: libdrivers-at32uc3a-speed_opt.r82
    ../../../../../../UTILS/LIBS/DSPLIB/AT32UCR2/IAR/: libdsp-at32ucr2-dspspeed_opt.r82
  group services
    ../../../../../../SERVICES/DELAY/: delay.c
    ../../../../../../COMPONENTS/DISPLAY/DIP204/: dip204.c
    ../../../../../../SERVICES/MOTOR_CONTROL/HALL_ESTIMATOR/: hall_estimator.c
    ../../../../../../SERVICES/MOTOR_CONTROL/MOTOR_DRIVER/BLDC_MOTOR/: pwm_drv.c
    ../../../../../../SERVICES/MOTOR_CONTROL/SVPWM/: svpwm.c
  group support
    ../../../../../../DRIVERS/INTC/: exception.s82
    ../../../../../../SERVICES/FREERTOS/Source/portable/IAR/AVR32_UC3/: read.c write.c
    ../../../../../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
  group utils
    ../../../../../../SERVICES/MOTOR_CONTROL/USHELL/: ascii.c ushell_task.c
    ../../: sensor_task.c
